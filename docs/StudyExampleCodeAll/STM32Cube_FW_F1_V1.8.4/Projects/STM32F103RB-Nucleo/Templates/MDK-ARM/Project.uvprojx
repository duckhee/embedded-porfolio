# Keil uVision project Project.uvprojx, settings and files
target STM32F103RB_Nucleo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F103RB_Nucleo
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,USE_STM32F1xx_NUCLEO
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../../../../Drivers/STM32F1xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32F1xx_Nucleo;../../../../Drivers/BSP/Adafruit_Shield
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM32F1xx_Nucleo
    ../../../../Drivers/BSP/STM32F1xx_Nucleo/: stm32f1xx_nucleo.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio.c stm32f1xx_hal_wwdg.c stm32f1xx_hal_flash.c stm32f1xx_hal_crc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_nand.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_pcd.c stm32f1xx_hal_uart.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_ll_usb.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_eth.c stm32f1xx_hal_exti.c stm32f1xx_hal_rtc.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_sd.c stm32f1xx_hal_i2s.c stm32f1xx_hal_spi.c stm32f1xx_hal_rcc.c stm32f1xx_ll_sdmmc.c stm32f1xx_hal_sram.c stm32f1xx_hal_nor.c stm32f1xx_hal_usart.c stm32f1xx_hal_adc.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_dac.c stm32f1xx_hal_i2c.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_irda.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal.c stm32f1xx_hal_pccard.c
  group Example/User
    ../Src/: stm32f1xx_hal_msp.c main.c stm32f1xx_it.c
  group Drivers/BSP/Adafruit_Shield
    ../../../../Drivers/BSP/Adafruit_Shield/: stm32_adafruit_lcd.c
  group Drivers/BSP/Components
    ../../../../Drivers/BSP/Components/st7735/: st7735.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Example/MDK-ARM
    ./: startup_stm32f103xb.s
target STM32F103RB_Nucleo_ASSERT_V6 (6070000::V6.7::.\ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: STM32F103RB_Nucleo
  c flags: Optim=4 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB,USE_STM32F1xx_NUCLEO
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.3.0
