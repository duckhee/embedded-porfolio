# Keil uVision project Project.uvprojx, settings and files
target STM3210C_EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM3210C_EVAL
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F107xC,USE_STM3210C_EVAL
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../../../../Drivers/STM32F1xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM3210C_EVAL;../../../../Drivers/BSP/Components/Common;../../../../Utilities/Log;../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Example/MDK-ARM
    ./: startup_stm32f107xc.s
  group Drivers/BSP/Components
    ../../../../Drivers/BSP/Components/st7735/: st7735.c
    ../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../../../Drivers/BSP/Components/ili9320/: ili9320.c
    ../../../../Drivers/BSP/Components/cs43l22/: cs43l22.c
    ../../../../Drivers/BSP/Components/ili9325/: ili9325.c
    ../../../../Drivers/BSP/Components/spfd5408/: spfd5408.c
    ../../../../Drivers/BSP/Components/stlm75/: stlm75.c
    ../../../../Drivers/BSP/Components/lis302dl/: lis302dl.c
    ../../../../Drivers/BSP/Components/hx8347d/: hx8347d.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_eth.c stm32f1xx_hal_exti.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pccard.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_tim.c stm32f1xx_ll_sdmmc.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_nor.c stm32f1xx_hal_irda.c stm32f1xx_hal_sram.c stm32f1xx_hal_adc.c stm32f1xx_hal_uart.c stm32f1xx_hal_spi.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_sd.c stm32f1xx_hal_cec.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_usart.c stm32f1xx_hal_nand.c stm32f1xx_hal_hcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_pwr.c stm32f1xx_ll_usb.c stm32f1xx_hal_pcd.c stm32f1xx_hal_i2s.c stm32f1xx_hal_smartcard.c stm32f1xx_hal.c stm32f1xx_hal_i2c.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_flash.c stm32f1xx_hal_wwdg.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_dac.c stm32f1xx_hal_rtc.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/BSP/STM3210C_EVAL
    ../../../../Drivers/BSP/STM3210C_EVAL/: stm3210c_eval_sd.c stm3210c_eval_lcd.c stm3210c_eval_io.c stm3210c_eval_accelerometer.c stm3210c_eval.c stm3210c_eval_eeprom.c stm3210c_eval_audio.c stm3210c_eval_ts.c
  group Example/User
    ../Src/: stm32f1xx_it.c stm32f1xx_hal_msp.c main.c
target STM3210C_EVAL_ASSERT_V6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: STM3210C_EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F107xC,USE_STM3210C_EVAL
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.3.0
