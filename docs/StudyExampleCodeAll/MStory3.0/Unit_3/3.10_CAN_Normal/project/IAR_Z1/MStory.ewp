# IAR project MStory.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; BOARD_DEF_MANGO_Z1
  ICCARM.CCIncludePath2: ..\..\inc; ..\..\cc2520; ..\..\..\..\Libraries\CMSIS\Core\CM3; ..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: MStory.hex
  ILINK.IlinkOutputFile: MStory.out
  ILINK.IlinkIcfFile: STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CC2520
    ../../cc2520/: basic_rf.c basic_rf_security.c cc2520_mango_porting.c hal_cc2520.c hal_int.c hal_rf.c hal_rf_security.c util.c
  group CMSIS
    ../../../../Libraries/CMSIS/Core/CM3/startup/iar/: startup_stm32f10x_md.s
    ../../../../Libraries/CMSIS/Core/CM3/: system_stm32f10x.c
  group src
    ../../src/: debug.c hw_config.c key.c led.c main.c stm32f10x_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c zigbee_test.c
  group STM32_USB-FS-Device_Driver
    ../../../../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group STM32F10x_StdPeriph_Driver
    ../../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
